<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simulator_fmcw_rcs</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>2**5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sweep_freq</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_cw</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_res</value></param>
<param><key>value</key><value>samp_rate/samp_cw*3e8/2/center_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_output_buffer</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>int((samp_up+samp_down+samp_cw)*2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5.9e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_down</value></param>
<param><key>value</key><value>samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_up</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res</value></param>
<param><key>value</key><value>3e8/2/sweep_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meas_duration</value></param>
<param><key>value</key><value>(samp_cw+samp_up+samp_down)/float(samp_rate)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>DOWN</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>protect_samp</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>c</key><value>1.0/decim_fac</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>CW</value></param>
<param><key>fftsize</key><value>samp_cw/decim_fac</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0</value></param>
<param><key>packet_num</key><value>0</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0</value></param>
<param><key>packet_num</key><value>1</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0_0</value></param>
<param><key>packet_num</key><value>2</value></param>
<param><key>packet_parts</key><value>(samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_cw</key><value>samp_cw</value></param>
<param><key>samp_up</key><value>samp_up</value></param>
<param><key>samp_down</key><value>samp_down</value></param>
<param><key>freq_cw</key><value>-sweep_freq/2</value></param>
<param><key>freq_sweep</key><value>sweep_freq</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>UP</value></param>
<param><key>fftsize</key><value>samp_up/decim_fac</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>radar_estimator_fmcw</key>
<param><key>id</key><value>radar_estimator_fmcw_0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>sweep_freq</key><value>sweep_freq</value></param>
<param><key>samp_up</key><value>samp_up/decim_fac</value></param>
<param><key>samp_down</key><value>samp_down/decim_fac</value></param>
<param><key>push_power</key><value>True</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>10e-9</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcs</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>radar_static_target_simulator_cc</key>
<param><key>id</key><value>radar_static_target_simulator_cc_0</value></param>
<param><key>range</key><value>value_range,</value></param>
<param><key>velocity</key><value>velocity,</value></param>
<param><key>rcs</key><value>rcs,</value></param>
<param><key>azimuth</key><value>0,</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>self_coupling_db</key><value>-10</value></param>
<param><key>rndm_phaseshift</key><value>True</value></param>
<param><key>self_coupling</key><value>True</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>packet_len</key><value>samp_cw/decim_fac</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>samp_protect</key><value>protect_samp</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.0/(samp_cw/decim_fac)</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0_0</value></param>
<param><key>packet_len</key><value>samp_up/decim_fac</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>samp_protect</key><value>protect_samp</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0_1</value></param>
<param><key>packet_len</key><value>samp_down/decim_fac</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>samp_protect</key><value>protect_samp</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.0/(samp_up/decim_fac)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.0/(samp_down/decim_fac)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-200</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>value_range</value></param>
<param><key>label</key><value>range</value></param>
<param><key>value</key><value>200</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>velocity</value></param>
<param><key>value</key><value>30</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>radar_estimator_rcs</key>
<param><key>id</key><value>radar_estimator_rcs_0</value></param>
<param><key>num_mean</key><value>10</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>antenna_gain_tx</key><value>0</value></param>
<param><key>antenna_gain_rx</key><value>0</value></param>
<param><key>usrp_gain_tx</key><value>0</value></param>
<param><key>usrp_gain_rx</key><value>0</value></param>
<param><key>power_tx</key><value>1</value></param>
<param><key>corr_factor</key><value>0.85</value></param>
<param><key>exponent</key><value>1</value></param>
</block>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_static_target_simulator_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>radar_static_target_simulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_split_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in DOWN</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in UP</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0</source_block_id><sink_block_id>radar_estimator_fmcw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in CW</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fmcw_0</source_block_id><sink_block_id>radar_estimator_rcs_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_rcs_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>radar_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>radar_find_max_peak_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>radar_find_max_peak_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
